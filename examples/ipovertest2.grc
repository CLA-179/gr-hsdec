options:
  parameters:
    author: clouda
    generate_options: qt_gui
    id: ipovertest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: variable_header_format_default_0
  id: variable_header_format_default
  parameters:
    access_code: '11010110011111111110000011101'
    bps: '1'
    threshold: '0'
  states: {}
- name: variable_rrc_filter_taps_0
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: '1.0'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1024'
    reference: '1.0'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_T
    period: '2000'
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '8'
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1,1]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1j,1,-1,-1j]'
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.1'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[1,0]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '0.7'
    loop_bw: '112.8e-3'
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: hsdec_variable_pack_dec_0
  id: hsdec_variable_pack_dec
  parameters:
    call: BG2FWT
    order: '2'
  states: {}
- name: hsdec_variable_pack_enc_0
  id: hsdec_variable_pack_enc
  parameters:
    call: BG2FWT
    preamble_len: '1024'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: variable_rrc_filter_taps_0
    type: ccc
  states: {state: disabled}
- name: lilacsat_sync_det_b_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '1000'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {state: disabled}
- name: lilacsat_sync_det_b_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '1000'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '8001'
    type: TCP_SERVER
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xFF'
    maxsize: '1000'
    minsize: '100'
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/5
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: '50'
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: '10'
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_feedforward_agc_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_repeat_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_repeat_0, '0', uhd_usrp_sink_0, '0']
- [blocks_repeat_0_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_repeat_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_map_bb_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_map_bb_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_repeat_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_map_bb_0, '0', hsdec_variable_pack_dec_0, '0']
- [digital_map_bb_0, '0', lilacsat_sync_det_b_0, '0']
- [digital_map_bb_0_0, '0', lilacsat_sync_det_b_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [hsdec_variable_pack_dec_0, out, blocks_message_debug_0, print]
- [hsdec_variable_pack_dec_0, out, virtual_sink_0, '0']
- [hsdec_variable_pack_enc_0, '0', blocks_repack_bits_bb_0, '0']
- [hsdec_variable_pack_enc_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_const_sink_x_1, '0']
- [interp_fir_filter_xxx_0, '0', uhd_usrp_sink_0, '0']
- [lilacsat_sync_det_b_0, out, blocks_message_debug_0, print]
- [lilacsat_sync_det_b_0_0, out, blocks_message_debug_0, print]
- [network_socket_pdu_0, pdus, hsdec_variable_pack_enc_0, in]
- [pdu_random_pdu_0, pdus, blocks_message_debug_0_0, print]
- [pdu_random_pdu_0, pdus, hsdec_variable_pack_enc_0, in]
- [uhd_usrp_source_0, '0', analog_feedforward_agc_cc_0, '0']
- [virtual_source_0, '0', network_socket_pdu_0, pdus]

metadata:
  file_format: 1

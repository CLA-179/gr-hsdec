options:
  parameters:
    author: clouda
    generate_options: qt_gui
    id: bpsk10m
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: chunk_num
  id: variable
  parameters:
    value: '6'
  states: {}
- name: chunk_samps
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: chunk_samps_u
  id: variable
  parameters:
    value: '70000'
  states: {}
- name: damp_factor
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    start: 70e6
    step: 1e3
    stop: 1e9
    value: 435e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '45'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '122.8e-3'
  states: {}
- name: loop_bw_1
  id: variable
  parameters:
    value: 2*3.1415926/100
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '40000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: t_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '37'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_2_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_2_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/clouda/tgrc/bpskrxd.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/clouda/tgrc/bpsktx
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: chunk_samps
    n: chunk_samps_u*chunk_num
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: chunk_samps
    n: chunk_samps_u*chunk_num
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_1
  id: blocks_keep_m_in_n
  parameters:
    m: chunk_samps
    n: chunk_samps_u*chunk_num
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_2
  id: blocks_keep_m_in_n
  parameters:
    m: chunk_samps
    n: chunk_samps_u*chunk_num
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_2_0
  id: blocks_keep_m_in_n
  parameters:
    m: chunk_samps
    n: chunk_samps_u*chunk_num
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_2_1
  id: blocks_keep_m_in_n
  parameters:
    m: chunk_samps
    n: chunk_samps_u*chunk_num
    offset: '0'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '10'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0_3
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0_3_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0_5
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0_5_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: 0*chunk_samps_u
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: 1*chunk_samps_u
    type: complex
  states: {}
- name: blocks_skiphead_0_1
  id: blocks_skiphead
  parameters:
    num_items: 2*chunk_samps_u
    type: complex
  states: {}
- name: blocks_skiphead_0_2
  id: blocks_skiphead
  parameters:
    num_items: 3*chunk_samps_u
    type: complex
  states: {}
- name: blocks_skiphead_0_2_0
  id: blocks_skiphead
  parameters:
    num_items: 4*chunk_samps_u
    type: complex
  states: {}
- name: blocks_skiphead_0_2_1
  id: blocks_skiphead
  parameters:
    num_items: 5*chunk_samps_u
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: chunk_samps
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: chunk_samps
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: chunk_samps
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_1_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: chunk_samps
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_1_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: chunk_samps
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_1_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: chunk_samps
    type: complex
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    name: 1-b
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_0
  id: blocks_tag_debug
  parameters:
    name: 1-a
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_1
  id: blocks_tag_debug
  parameters:
    name: '2'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_2
  id: blocks_tag_debug
  parameters:
    name: '3'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_3
  id: blocks_tag_debug
  parameters:
    name: '4'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '6'
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_2
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_2_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_2_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_1
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_2
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_2_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_2_1
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw_1
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_1
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_2
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_2_0
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_2_1
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: hsdec_frame_sync_0
  id: hsdec_frame_sync
  parameters:
    block_size: '35000'
    code: '0x1acffc1d'
    len: 1024+4
  states: {}
- name: hsdec_frame_sync_0_0
  id: hsdec_frame_sync
  parameters:
    block_size: '35000'
    code: '0x1acffc1d'
    len: 1024+4
  states: {}
- name: hsdec_frame_sync_0_1
  id: hsdec_frame_sync
  parameters:
    block_size: '35000'
    code: '0x1acffc1d'
    len: 1024+4
  states: {}
- name: hsdec_frame_sync_0_2
  id: hsdec_frame_sync
  parameters:
    block_size: '35000'
    code: '0x1acffc1d'
    len: 1024+4
  states: {}
- name: hsdec_frame_sync_0_2_0
  id: hsdec_frame_sync
  parameters:
    block_size: '35000'
    code: '0x1acffc1d'
    len: 1024+4
  states: {}
- name: hsdec_frame_sync_0_2_1
  id: hsdec_frame_sync
  parameters:
    block_size: '35000'
    code: '0x1acffc1d'
    len: 1024+4
  states: {}
- name: hsdec_packet_filter_0
  id: hsdec_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_packet_filter_0_0
  id: hsdec_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_packet_filter_0_1
  id: hsdec_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_packet_filter_0_2
  id: hsdec_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_packet_filter_0_2_0
  id: hsdec_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_packet_filter_0_2_1
  id: hsdec_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    dev_addr: ''
    gain0: t_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    dev_addr: ''
    gain0: gain
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_real_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_complex_to_real_0_1, '0', digital_binary_slicer_fb_0_1, '0']
- [blocks_complex_to_real_0_2, '0', digital_binary_slicer_fb_0_2, '0']
- [blocks_complex_to_real_0_2_0, '0', digital_binary_slicer_fb_0_2_0, '0']
- [blocks_complex_to_real_0_2_1, '0', digital_binary_slicer_fb_0_2_1, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_keep_m_in_n_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_keep_m_in_n_0_1, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [blocks_keep_m_in_n_0_2, '0', blocks_stream_to_tagged_stream_0_1_0, '0']
- [blocks_keep_m_in_n_0_2_0, '0', blocks_stream_to_tagged_stream_0_1_0_0, '0']
- [blocks_keep_m_in_n_0_2_1, '0', blocks_stream_to_tagged_stream_0_1_0_1, '0']
- [blocks_multiply_const_xx_0, '0', blocks_skiphead_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_skiphead_0_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_skiphead_0_1, '0']
- [blocks_multiply_const_xx_0, '0', blocks_skiphead_0_2, '0']
- [blocks_multiply_const_xx_0, '0', blocks_skiphead_0_2_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_skiphead_0_2_1, '0']
- [blocks_skiphead_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_skiphead_0_0, '0', blocks_keep_m_in_n_0_0, '0']
- [blocks_skiphead_0_1, '0', blocks_keep_m_in_n_0_1, '0']
- [blocks_skiphead_0_2, '0', blocks_keep_m_in_n_0_2, '0']
- [blocks_skiphead_0_2_0, '0', blocks_keep_m_in_n_0_2_0, '0']
- [blocks_skiphead_0_2_1, '0', blocks_keep_m_in_n_0_2_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', digital_symbol_sync_xx_0_1, '0']
- [blocks_stream_to_tagged_stream_0_1_0, '0', digital_symbol_sync_xx_0_2, '0']
- [blocks_stream_to_tagged_stream_0_1_0_0, '0', digital_symbol_sync_xx_0_2_0, '0']
- [blocks_stream_to_tagged_stream_0_1_0_1, '0', digital_symbol_sync_xx_0_2_1, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_file_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0, '0', blocks_skiphead_0, '0']
- [blocks_throttle_0, '0', blocks_skiphead_0_0, '0']
- [blocks_throttle_0, '0', blocks_skiphead_0_1, '0']
- [blocks_throttle_0, '0', blocks_skiphead_0_2, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', hsdec_frame_sync_0, '0']
- [digital_binary_slicer_fb_0_0, '0', hsdec_frame_sync_0_0, '0']
- [digital_binary_slicer_fb_0_1, '0', hsdec_frame_sync_0_1, '0']
- [digital_binary_slicer_fb_0_2, '0', hsdec_frame_sync_0_2, '0']
- [digital_binary_slicer_fb_0_2_0, '0', hsdec_frame_sync_0_2_0, '0']
- [digital_binary_slicer_fb_0_2_1, '0', hsdec_frame_sync_0_2_1, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_complex_to_real_0_0, '0']
- [digital_costas_loop_cc_0_1, '0', blocks_complex_to_real_0_1, '0']
- [digital_costas_loop_cc_0_2, '0', blocks_complex_to_real_0_2, '0']
- [digital_costas_loop_cc_0_2_0, '0', blocks_complex_to_real_0_2_0, '0']
- [digital_costas_loop_cc_0_2_1, '0', blocks_complex_to_real_0_2_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0_1, '0', digital_costas_loop_cc_0_1, '0']
- [digital_symbol_sync_xx_0_2, '0', digital_costas_loop_cc_0_2, '0']
- [digital_symbol_sync_xx_0_2_0, '0', digital_costas_loop_cc_0_2_0, '0']
- [digital_symbol_sync_xx_0_2_1, '0', digital_costas_loop_cc_0_2_1, '0']
- [hsdec_frame_sync_0, '0', blocks_tag_debug_1_0, '0']
- [hsdec_frame_sync_0, '0', hsdec_packet_filter_0, '0']
- [hsdec_frame_sync_0_0, '0', hsdec_packet_filter_0_0, '0']
- [hsdec_frame_sync_0_1, '0', hsdec_packet_filter_0_1, '0']
- [hsdec_frame_sync_0_2, '0', hsdec_packet_filter_0_2, '0']
- [hsdec_frame_sync_0_2_0, '0', hsdec_packet_filter_0_2_0, '0']
- [hsdec_frame_sync_0_2_1, '0', hsdec_packet_filter_0_2_1, '0']
- [hsdec_packet_filter_0, '0', blocks_null_sink_0_0, '0']
- [hsdec_packet_filter_0, '0', blocks_tag_debug_1, '0']
- [hsdec_packet_filter_0, '0', blocks_tagged_stream_mux_0, '0']
- [hsdec_packet_filter_0_0, '0', blocks_null_sink_0_0_1, '0']
- [hsdec_packet_filter_0_0, '0', blocks_tag_debug_1_1, '0']
- [hsdec_packet_filter_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [hsdec_packet_filter_0_1, '0', blocks_null_sink_0_0_3, '0']
- [hsdec_packet_filter_0_1, '0', blocks_tag_debug_1_2, '0']
- [hsdec_packet_filter_0_1, '0', blocks_tagged_stream_mux_0, '2']
- [hsdec_packet_filter_0_2, '0', blocks_null_sink_0_0_5, '0']
- [hsdec_packet_filter_0_2, '0', blocks_tag_debug_1_3, '0']
- [hsdec_packet_filter_0_2, '0', blocks_tagged_stream_mux_0, '3']
- [hsdec_packet_filter_0_2_0, '0', blocks_null_sink_0_0_3_0, '0']
- [hsdec_packet_filter_0_2_0, '0', blocks_tagged_stream_mux_0, '4']
- [hsdec_packet_filter_0_2_1, '0', blocks_null_sink_0_0_5_0, '0']
- [hsdec_packet_filter_0_2_1, '0', blocks_tagged_stream_mux_0, '5']
- [uhd_usrp_source_0, '0', blocks_multiply_const_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1

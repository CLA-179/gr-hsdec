options:
  parameters:
    author: xh
    generate_options: qt_gui
    id: tx_512k
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc_t
  id: variable_qtgui_range
  parameters:
    start: 7e9
    step: 1e3
    stop: 7.8e9
    value: 7239e6
  states: {}
- name: gain_t
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '20'
  states: {}
- name: samp_rate_t
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repack_bits_bb_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_2_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-0.707,0.707]'
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-0.707j,0.707j]'
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[0.5-0.5j,-0.5+0.5j]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-0.5-0.5j,0.5+0.5j]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,0,1]'
  states: {}
- name: digital_map_bb_0_1
  id: digital_map_bb
  parameters:
    map: '[0,0,1,1]'
  states: {}
- name: hsdec_rs_4_0
  id: hsdec_rs_4
  parameters: {}
  states: {}
- name: hsdec_send_pack_0
  id: hsdec_send_pack
  parameters: {}
  states: {}
- name: lilacsat_encode27_bb_0_0
  id: lilacsat_encode27_bb
  parameters: {}
  states: {}
- name: lilacsat_encode27_bb_0_1
  id: lilacsat_encode27_bb
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '52002'
    type: TCP_SERVER
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc_t-6600e6
    gain0: gain_t
    samp_rate: samp_rate_t
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_repeat_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_map_bb_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_map_bb_0_1, '0']
- [blocks_repack_bits_bb_2, '0', lilacsat_encode27_bb_0_0, '0']
- [blocks_repack_bits_bb_2_0, '0', lilacsat_encode27_bb_0_1, '0']
- [blocks_repeat_0, '0', blocks_null_sink_1, '0']
- [blocks_repeat_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_repeat_0, '0', uhd_usrp_sink_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_add_xx_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_add_xx_0, '1']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_add_xx_0, '1']
- [digital_chunks_to_symbols_xx_0_1, '0', blocks_add_xx_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_repack_bits_bb_2_0, '0']
- [digital_map_bb_0_1, '0', blocks_repack_bits_bb_2, '0']
- [hsdec_rs_4_0, out, hsdec_send_pack_0, in]
- [hsdec_send_pack_0, '0', blocks_repack_bits_bb_0, '0']
- [lilacsat_encode27_bb_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [lilacsat_encode27_bb_0_0, '0', digital_chunks_to_symbols_xx_0_1, '0']
- [lilacsat_encode27_bb_0_1, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [lilacsat_encode27_bb_0_1, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [network_socket_pdu_0, pdus, hsdec_rs_4_0, in]

metadata:
  file_format: 1

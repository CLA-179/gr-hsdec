options:
  parameters:
    author: clouda
    generate_options: qt_gui
    id: loopback_512k
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    start: 7e9
    step: 1e3
    stop: 8e9
    value: 7826.5e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: t_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '20'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/clouda/Desktop/recv_spl.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_2
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repack_bits_bb_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_2_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: byte
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: byte
  states: {}
- name: blocks_stream_mux_0_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: byte
  states: {}
- name: blocks_stream_mux_0_0_1
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: byte
  states: {}
- name: blocks_stream_mux_0_0_2
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: byte
  states: {}
- name: blocks_stream_mux_0_1
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: byte
  states: {}
- name: blocks_stream_mux_0_2
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: byte
  states: {}
- name: blocks_stream_mux_0_3
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-0.5-0.5j,0.5+0.5j]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[0.5-0.5j,-0.5+0.5j]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1j,1j]'
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1,1]'
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '100e-3'
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '100e-3'
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,0,1,1]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,0,1]'
  states: {}
- name: digital_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[1,0]'
  states: {}
- name: digital_map_bb_1_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_map_bb_1_0_0
  id: digital_map_bb
  parameters:
    map: '[1,0]'
  states: {}
- name: digital_map_bb_1_1
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_map_bb_1_2
  id: digital_map_bb
  parameters:
    map: '[1,0]'
  states: {}
- name: digital_map_bb_1_2_0
  id: digital_map_bb
  parameters:
    map: '[1,0]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '2'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dslwp_attach_sync_marker_0
  id: dslwp_attach_sync_marker
  parameters:
    check_length: 'False'
    data_format: '2'
    marker: '[0x1a,0xcf, 0xfc,0x1d]'
    msg_len: '1020'
    pass_other_length: 'True'
  states: {}
- name: hsdec_rs_4_0
  id: hsdec_rs_4
  parameters: {}
  states: {}
- name: hsdec_send_pack_0
  id: hsdec_send_pack
  parameters: {}
  states: {}
- name: lilacsat_encode27_bb_0_0
  id: lilacsat_encode27_bb
  parameters: {}
  states: {}
- name: lilacsat_encode27_bb_0_1
  id: lilacsat_encode27_bb
  parameters: {}
  states: {}
- name: lilacsat_sync_det_b_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0_1
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0_2
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_1
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_2
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_3
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_vitfilt27_fb_0
  id: lilacsat_vitfilt27_fb
  parameters: {}
  states: {}
- name: lilacsat_vitfilt27_fb_0_0
  id: lilacsat_vitfilt27_fb
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '52002'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc - 6600e6
    gain0: t_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '40000000'
    center_freq0: fc - 6600e6
    gain0: gain
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_add_xx_0, '0', blocks_repeat_0, '0']
- [blocks_add_xx_0, '0', digital_costas_loop_cc_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_float_0, '0', lilacsat_vitfilt27_fb_0, '0']
- [blocks_complex_to_float_0, '1', lilacsat_vitfilt27_fb_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', blocks_repeat_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_map_bb_0_0, '0']
- [blocks_repack_bits_bb_2, '0', lilacsat_encode27_bb_0_0, '0']
- [blocks_repack_bits_bb_2_0, '0', lilacsat_encode27_bb_0_1, '0']
- [blocks_repeat_0, '0', uhd_usrp_sink_0, '0']
- [blocks_stream_mux_0, '0', lilacsat_sync_det_b_0, '0']
- [blocks_stream_mux_0_0, '0', lilacsat_sync_det_b_0_0, '0']
- [blocks_stream_mux_0_0_0, '0', lilacsat_sync_det_b_0_0_0, '0']
- [blocks_stream_mux_0_0_1, '0', lilacsat_sync_det_b_0_0_1, '0']
- [blocks_stream_mux_0_0_2, '0', lilacsat_sync_det_b_0_0_2, '0']
- [blocks_stream_mux_0_1, '0', lilacsat_sync_det_b_0_1, '0']
- [blocks_stream_mux_0_2, '0', lilacsat_sync_det_b_0_2, '0']
- [blocks_stream_mux_0_3, '0', lilacsat_sync_det_b_0_3, '0']
- [blocks_throttle_0, '0', blocks_complex_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_stream_mux_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', digital_map_bb_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_map_bb_1_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_map_bb_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_stream_mux_0, '1']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_map_bb_1_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_map_bb_1_2, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_map_bb_1_2_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_add_xx_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_add_xx_0, '1']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_add_xx_0, '1']
- [digital_chunks_to_symbols_xx_0_1, '0', blocks_add_xx_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_float_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_throttle_0, '0']
- [digital_map_bb_0, '0', blocks_repack_bits_bb_2, '0']
- [digital_map_bb_0_0, '0', blocks_repack_bits_bb_2_0, '0']
- [digital_map_bb_1, '0', blocks_stream_mux_0_0_0, '1']
- [digital_map_bb_1, '0', blocks_stream_mux_0_1, '0']
- [digital_map_bb_1_0, '0', blocks_stream_mux_0_0_1, '1']
- [digital_map_bb_1_0, '0', blocks_stream_mux_0_2, '0']
- [digital_map_bb_1_0_0, '0', blocks_stream_mux_0_0_2, '1']
- [digital_map_bb_1_0_0, '0', blocks_stream_mux_0_3, '0']
- [digital_map_bb_1_1, '0', blocks_stream_mux_0_0_0, '0']
- [digital_map_bb_1_1, '0', blocks_stream_mux_0_1, '1']
- [digital_map_bb_1_2, '0', blocks_stream_mux_0_0_1, '0']
- [digital_map_bb_1_2, '0', blocks_stream_mux_0_2, '1']
- [digital_map_bb_1_2_0, '0', blocks_stream_mux_0_0_2, '0']
- [digital_map_bb_1_2_0, '0', blocks_stream_mux_0_3, '1']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [dslwp_attach_sync_marker_0, out, network_socket_pdu_1, pdus]
- [hsdec_rs_4_0, out, hsdec_send_pack_0, in]
- [hsdec_send_pack_0, '0', blocks_repack_bits_bb_0, '0']
- [lilacsat_encode27_bb_0_0, '0', blocks_char_to_float_0, '0']
- [lilacsat_encode27_bb_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [lilacsat_encode27_bb_0_0, '0', digital_chunks_to_symbols_xx_0_1, '0']
- [lilacsat_encode27_bb_0_1, '0', blocks_char_to_float_0_0, '0']
- [lilacsat_encode27_bb_0_1, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [lilacsat_encode27_bb_0_1, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [lilacsat_sync_det_b_0, out, blocks_message_debug_0, print]
- [lilacsat_sync_det_b_0, out, dslwp_attach_sync_marker_0, in]
- [lilacsat_sync_det_b_0_0, out, blocks_message_debug_0, print]
- [lilacsat_sync_det_b_0_0, out, dslwp_attach_sync_marker_0, in]
- [lilacsat_sync_det_b_0_0_0, out, blocks_message_debug_0_0, print]
- [lilacsat_sync_det_b_0_0_0, out, dslwp_attach_sync_marker_0, in]
- [lilacsat_sync_det_b_0_0_1, out, blocks_message_debug_0_1, print]
- [lilacsat_sync_det_b_0_0_1, out, dslwp_attach_sync_marker_0, in]
- [lilacsat_sync_det_b_0_0_2, out, blocks_message_debug_0_2, print]
- [lilacsat_sync_det_b_0_0_2, out, dslwp_attach_sync_marker_0, in]
- [lilacsat_sync_det_b_0_1, out, blocks_message_debug_0_0, print]
- [lilacsat_sync_det_b_0_1, out, dslwp_attach_sync_marker_0, in]
- [lilacsat_sync_det_b_0_2, out, blocks_message_debug_0_1, print]
- [lilacsat_sync_det_b_0_2, out, dslwp_attach_sync_marker_0, in]
- [lilacsat_sync_det_b_0_3, out, blocks_message_debug_0_2, print]
- [lilacsat_sync_det_b_0_3, out, dslwp_attach_sync_marker_0, in]
- [lilacsat_vitfilt27_fb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [lilacsat_vitfilt27_fb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [network_socket_pdu_0, pdus, hsdec_rs_4_0, in]
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    author: clouda
    generate_options: qt_gui
    id: selftest_10m
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: damp_factor
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    start: 7e9
    step: 1e3
    stop: 8e9
    value: 7826.5e6
  states: {}
- name: fc_t
  id: variable_qtgui_range
  parameters:
    start: 7e9
    step: 1e3
    stop: 8e9
    value: 7826.5e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '35'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '122.8e-3'
  states: {}
- name: loop_bw_1
  id: variable
  parameters:
    value: '100e-3'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: t_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '20'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./bpskrxd.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/xh/桌面/selftest.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/xh/文档/qpskwav.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '100000'
    n: '280000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: '100000'
    n: '280000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_1
  id: blocks_keep_m_in_n
  parameters:
    m: '100000'
    n: '280000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_2
  id: blocks_keep_m_in_n
  parameters:
    m: '100000'
    n: '280000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '0'
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '70000'
    type: complex
  states: {}
- name: blocks_skiphead_0_1
  id: blocks_skiphead
  parameters:
    num_items: '140000'
    type: complex
  states: {}
- name: blocks_skiphead_0_2
  id: blocks_skiphead
  parameters:
    num_items: '210000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_1_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100000'
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    name: '1'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_0
  id: blocks_tag_debug
  parameters:
    name: 1-a
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_0_0
  id: blocks_tag_debug
  parameters:
    name: 3-a
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_0_1
  id: blocks_tag_debug
  parameters:
    name: 4-a
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_0_2
  id: blocks_tag_debug
  parameters:
    name: 2-a
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_1
  id: blocks_tag_debug
  parameters:
    name: '2'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_2
  id: blocks_tag_debug
  parameters:
    name: '3'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_3
  id: blocks_tag_debug
  parameters:
    name: '4'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    minoutbuf: 70000*4
    ninputs: '4'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_2
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw_1
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_map_bb_0_2
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_map_bb_0_3
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_1
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_2
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dslwp_attach_sync_marker_0
  id: dslwp_attach_sync_marker
  parameters:
    check_length: 'False'
    data_format: '2'
    marker: '[0x1a,0xcf, 0xfc,0x1d]'
    msg_len: '1020'
    pass_other_length: 'True'
  states: {}
- name: hsdec_qpsk_frame_sync_0
  id: hsdec_qpsk_frame_sync
  parameters:
    block_size: 70000*2
    code: '0x1acffc1d'
    len: '1020'
  states: {}
- name: hsdec_qpsk_frame_sync_0_0
  id: hsdec_qpsk_frame_sync
  parameters:
    block_size: 70000*2
    code: '0x1acffc1d'
    len: '1020'
  states: {}
- name: hsdec_qpsk_frame_sync_0_1
  id: hsdec_qpsk_frame_sync
  parameters:
    block_size: 70000*2
    code: '0x1acffc1d'
    len: '1020'
  states: {}
- name: hsdec_qpsk_frame_sync_0_2
  id: hsdec_qpsk_frame_sync
  parameters:
    block_size: 70000*2
    code: '0x1acffc1d'
    len: '1020'
  states: {}
- name: hsdec_qpsk_packet_filter_0
  id: hsdec_qpsk_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_qpsk_packet_filter_0_0
  id: hsdec_qpsk_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_qpsk_packet_filter_0_1
  id: hsdec_qpsk_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_qpsk_packet_filter_0_2
  id: hsdec_qpsk_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_sequential_mux_0
  id: hsdec_sequential_mux
  parameters:
    n: '70000'
  states: {state: disabled}
- name: lilacsat_sync_det_b_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {state: disabled}
- name: lilacsat_sync_det_b_1
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 192.168.1.118
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {state: disabled}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_2
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc_t - 6600e6
    gain0: t_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '40000000'
    center_freq0: fc - 6600e6
    gain0: gain
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_skiphead_0, '0']
- [analog_agc_xx_0, '0', blocks_skiphead_0_0, '0']
- [analog_agc_xx_0, '0', blocks_skiphead_0_1, '0']
- [analog_agc_xx_0, '0', blocks_skiphead_0_2, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_keep_m_in_n_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_keep_m_in_n_0_1, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [blocks_keep_m_in_n_0_2, '0', blocks_stream_to_tagged_stream_0_1_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_skiphead_0_0, '0', blocks_keep_m_in_n_0_0, '0']
- [blocks_skiphead_0_1, '0', blocks_keep_m_in_n_0_1, '0']
- [blocks_skiphead_0_2, '0', blocks_keep_m_in_n_0_2, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', digital_symbol_sync_xx_0_1, '0']
- [blocks_stream_to_tagged_stream_0_1_0, '0', digital_symbol_sync_xx_0_2, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_file_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_tag_debug_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', lilacsat_sync_det_b_0, '0']
- [blocks_tagged_stream_mux_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle_0, '0', blocks_skiphead_0, '0']
- [blocks_throttle_0, '0', blocks_skiphead_0_0, '0']
- [blocks_throttle_0, '0', blocks_skiphead_0_1, '0']
- [blocks_throttle_0, '0', blocks_skiphead_0_2, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', lilacsat_sync_det_b_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_map_bb_0_2, '0']
- [digital_constellation_decoder_cb_0_0_1, '0', digital_map_bb_0_3, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0_1, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_costas_loop_cc_0_1, '0', qtgui_const_sink_x_0_1, '0']
- [digital_costas_loop_cc_0_2, '0', digital_constellation_decoder_cb_0_0_1, '0']
- [digital_costas_loop_cc_0_2, '0', qtgui_const_sink_x_0_2, '0']
- [digital_map_bb_0, '0', hsdec_qpsk_frame_sync_0, '0']
- [digital_map_bb_0_0, '0', hsdec_qpsk_frame_sync_0_0, '0']
- [digital_map_bb_0_2, '0', hsdec_qpsk_frame_sync_0_2, '0']
- [digital_map_bb_0_3, '0', hsdec_qpsk_frame_sync_0_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0_1, '0', digital_costas_loop_cc_0_1, '0']
- [digital_symbol_sync_xx_0_2, '0', digital_costas_loop_cc_0_2, '0']
- [dslwp_attach_sync_marker_0, out, network_socket_pdu_1, pdus]
- [dslwp_attach_sync_marker_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [hsdec_qpsk_frame_sync_0, '0', blocks_tag_debug_1_0, '0']
- [hsdec_qpsk_frame_sync_0, '0', hsdec_qpsk_packet_filter_0, '0']
- [hsdec_qpsk_frame_sync_0_0, '0', blocks_tag_debug_1_0_2, '0']
- [hsdec_qpsk_frame_sync_0_0, '0', hsdec_qpsk_packet_filter_0_0, '0']
- [hsdec_qpsk_frame_sync_0_1, '0', blocks_tag_debug_1_0_1, '0']
- [hsdec_qpsk_frame_sync_0_1, '0', hsdec_qpsk_packet_filter_0_2, '0']
- [hsdec_qpsk_frame_sync_0_2, '0', blocks_tag_debug_1_0_0, '0']
- [hsdec_qpsk_frame_sync_0_2, '0', hsdec_qpsk_packet_filter_0_1, '0']
- [hsdec_qpsk_packet_filter_0, '0', blocks_tag_debug_1, '0']
- [hsdec_qpsk_packet_filter_0, '0', blocks_tagged_stream_mux_0, '0']
- [hsdec_qpsk_packet_filter_0, '0', hsdec_sequential_mux_0, '0']
- [hsdec_qpsk_packet_filter_0_0, '0', blocks_tag_debug_1_1, '0']
- [hsdec_qpsk_packet_filter_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [hsdec_qpsk_packet_filter_0_0, '0', hsdec_sequential_mux_0, '1']
- [hsdec_qpsk_packet_filter_0_1, '0', blocks_tag_debug_1_2, '0']
- [hsdec_qpsk_packet_filter_0_1, '0', blocks_tagged_stream_mux_0, '2']
- [hsdec_qpsk_packet_filter_0_1, '0', hsdec_sequential_mux_0, '2']
- [hsdec_qpsk_packet_filter_0_2, '0', blocks_tag_debug_1_3, '0']
- [hsdec_qpsk_packet_filter_0_2, '0', blocks_tagged_stream_mux_0, '3']
- [hsdec_qpsk_packet_filter_0_2, '0', hsdec_sequential_mux_0, '3']
- [hsdec_sequential_mux_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [lilacsat_sync_det_b_0, out, network_socket_pdu_0, pdus]
- [lilacsat_sync_det_b_1, out, blocks_message_debug_0, print]
- [lilacsat_sync_det_b_1, out, dslwp_attach_sync_marker_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_1, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, network_socket_pdu_0, pdus]
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1

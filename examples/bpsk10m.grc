options:
  parameters:
    author: clouda
    generate_options: qt_gui
    id: bpsk10m
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: damp_factor
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    start: 70e6
    step: 1e3
    stop: 1e9
    value: 435e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '67'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '122.8e-3'
  states: {}
- name: loop_bw_1
  id: variable
  parameters:
    value: 2*3.1415926/100
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: t_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '69'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./bpskrxd.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./bpsktx
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '100000'
    n: '280000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: '100000'
    n: '280000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_1
  id: blocks_keep_m_in_n
  parameters:
    m: '100000'
    n: '280000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_2
  id: blocks_keep_m_in_n
  parameters:
    m: '100000'
    n: '280000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '0'
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '70000'
    type: complex
  states: {}
- name: blocks_skiphead_0_1
  id: blocks_skiphead
  parameters:
    num_items: '140000'
    type: complex
  states: {}
- name: blocks_skiphead_0_2
  id: blocks_skiphead
  parameters:
    num_items: '210000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_1_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100000'
    type: complex
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    name: 1-b
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_0
  id: blocks_tag_debug
  parameters:
    name: 1-a
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_1
  id: blocks_tag_debug
  parameters:
    name: '2'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_2
  id: blocks_tag_debug
  parameters:
    name: '3'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_3
  id: blocks_tag_debug
  parameters:
    name: '4'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '4'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_2
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_1
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_2
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw_1
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_1
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_2
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: hsdec_frame_sync_0
  id: hsdec_frame_sync
  parameters:
    block_size: '35000'
    code: '0x1acffc1d'
    len: 1024+4
  states: {}
- name: hsdec_frame_sync_0_0
  id: hsdec_frame_sync
  parameters:
    block_size: '35000'
    code: '0x1acffc1d'
    len: 1024+4
  states: {}
- name: hsdec_frame_sync_0_1
  id: hsdec_frame_sync
  parameters:
    block_size: '35000'
    code: '0x1acffc1d'
    len: 1024+4
  states: {}
- name: hsdec_frame_sync_0_2
  id: hsdec_frame_sync
  parameters:
    block_size: '35000'
    code: '0x1acffc1d'
    len: 1024+4
  states: {}
- name: hsdec_packet_filter_0
  id: hsdec_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_packet_filter_0_0
  id: hsdec_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_packet_filter_0_1
  id: hsdec_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_packet_filter_0_2
  id: hsdec_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: t_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_real_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_complex_to_real_0_1, '0', digital_binary_slicer_fb_0_1, '0']
- [blocks_complex_to_real_0_2, '0', digital_binary_slicer_fb_0_2, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_keep_m_in_n_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_keep_m_in_n_0_1, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [blocks_keep_m_in_n_0_2, '0', blocks_stream_to_tagged_stream_0_1_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_skiphead_0_0, '0', blocks_keep_m_in_n_0_0, '0']
- [blocks_skiphead_0_1, '0', blocks_keep_m_in_n_0_1, '0']
- [blocks_skiphead_0_2, '0', blocks_keep_m_in_n_0_2, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', digital_symbol_sync_xx_0_1, '0']
- [blocks_stream_to_tagged_stream_0_1_0, '0', digital_symbol_sync_xx_0_2, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_file_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0, '0', blocks_skiphead_0, '0']
- [blocks_throttle_0, '0', blocks_skiphead_0_0, '0']
- [blocks_throttle_0, '0', blocks_skiphead_0_1, '0']
- [blocks_throttle_0, '0', blocks_skiphead_0_2, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', hsdec_frame_sync_0, '0']
- [digital_binary_slicer_fb_0_0, '0', hsdec_frame_sync_0_0, '0']
- [digital_binary_slicer_fb_0_1, '0', hsdec_frame_sync_0_1, '0']
- [digital_binary_slicer_fb_0_2, '0', hsdec_frame_sync_0_2, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_complex_to_real_0_0, '0']
- [digital_costas_loop_cc_0_1, '0', blocks_complex_to_real_0_1, '0']
- [digital_costas_loop_cc_0_2, '0', blocks_complex_to_real_0_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0_1, '0', digital_costas_loop_cc_0_1, '0']
- [digital_symbol_sync_xx_0_2, '0', digital_costas_loop_cc_0_2, '0']
- [hsdec_frame_sync_0, '0', blocks_tag_debug_1_0, '0']
- [hsdec_frame_sync_0, '0', hsdec_packet_filter_0, '0']
- [hsdec_frame_sync_0_0, '0', hsdec_packet_filter_0_0, '0']
- [hsdec_frame_sync_0_1, '0', hsdec_packet_filter_0_1, '0']
- [hsdec_frame_sync_0_2, '0', hsdec_packet_filter_0_2, '0']
- [hsdec_packet_filter_0, '0', blocks_tag_debug_1, '0']
- [hsdec_packet_filter_0, '0', blocks_tagged_stream_mux_0, '0']
- [hsdec_packet_filter_0_0, '0', blocks_tag_debug_1_1, '0']
- [hsdec_packet_filter_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [hsdec_packet_filter_0_1, '0', blocks_tag_debug_1_2, '0']
- [hsdec_packet_filter_0_1, '0', blocks_tagged_stream_mux_0, '2']
- [hsdec_packet_filter_0_2, '0', blocks_tag_debug_1_3, '0']
- [hsdec_packet_filter_0_2, '0', blocks_tagged_stream_mux_0, '3']
- [uhd_usrp_source_0, '0', blocks_skiphead_0, '0']
- [uhd_usrp_source_0, '0', blocks_skiphead_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_skiphead_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_skiphead_0_2, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1

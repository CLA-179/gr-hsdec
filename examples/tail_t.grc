options:
  parameters:
    author: clouda
    generate_options: qt_gui
    id: tail_t
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: 256*4
    value: '744'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '127'
    freq: '32'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: byte
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '512'
    n: '1024'
    offset: '0'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: '512'
    n: '1024'
    offset: '0'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_0_1
  id: blocks_keep_m_in_n
  parameters:
    m: '512'
    n: '1024'
    offset: '0'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_0_2
  id: blocks_keep_m_in_n
  parameters:
    m: '512'
    n: '1024'
    offset: '0'
    type: byte
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '0'
    type: byte
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '256'
    type: byte
  states: {}
- name: blocks_skiphead_0_1
  id: blocks_skiphead
  parameters:
    num_items: '512'
    type: byte
  states: {}
- name: blocks_skiphead_0_2
  id: blocks_skiphead
  parameters:
    num_items: '768'
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: hsdec_sequential_mux_0
  id: hsdec_sequential_mux
  parameters:
    n: '256'
  states: {}
- name: hsdec_tail_0
  id: hsdec_tail
  parameters:
    m: '512'
    n: '256'
  states: {}
- name: hsdec_tail_0_0
  id: hsdec_tail
  parameters:
    m: '512'
    n: '256'
  states: {}
- name: hsdec_tail_0_1
  id: hsdec_tail
  parameters:
    m: '512'
    n: '256'
  states: {}
- name: hsdec_tail_0_2
  id: hsdec_tail
  parameters:
    m: '512'
    n: '256'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    size: 1024*4
    srate: samp_rate*4
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024*4
    srate: samp_rate*4
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: raw
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: raw
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_skiphead_0, '0']
- [analog_sig_source_x_0, '0', blocks_skiphead_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_skiphead_0_1, '0']
- [analog_sig_source_x_0, '0', blocks_skiphead_0_2, '0']
- [analog_sig_source_x_0, '0', virtual_sink_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_char_to_float_0_0_1, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_char_to_float_0_0_1_0, '0', qtgui_time_sink_x_0_0, '3']
- [blocks_char_to_float_0_1, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0_1_0, '0', blocks_sub_xx_0, '1']
- [blocks_delay_0, '0', blocks_char_to_float_0_1_0, '0']
- [blocks_keep_m_in_n_0, '0', hsdec_tail_0, '0']
- [blocks_keep_m_in_n_0_0, '0', hsdec_tail_0_0, '0']
- [blocks_keep_m_in_n_0_1, '0', hsdec_tail_0_2, '0']
- [blocks_keep_m_in_n_0_2, '0', hsdec_tail_0_1, '0']
- [blocks_skiphead_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_skiphead_0_0, '0', blocks_keep_m_in_n_0_0, '0']
- [blocks_skiphead_0_1, '0', blocks_keep_m_in_n_0_1, '0']
- [blocks_skiphead_0_2, '0', blocks_keep_m_in_n_0_2, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [hsdec_sequential_mux_0, '0', blocks_char_to_float_0_1, '0']
- [hsdec_tail_0, '0', blocks_char_to_float_0_0, '0']
- [hsdec_tail_0, '0', hsdec_sequential_mux_0, '0']
- [hsdec_tail_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [hsdec_tail_0_0, '0', hsdec_sequential_mux_0, '1']
- [hsdec_tail_0_1, '0', blocks_char_to_float_0_0_1_0, '0']
- [hsdec_tail_0_1, '0', hsdec_sequential_mux_0, '3']
- [hsdec_tail_0_2, '0', blocks_char_to_float_0_0_1, '0']
- [hsdec_tail_0_2, '0', hsdec_sequential_mux_0, '2']
- [virtual_source_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    author: xh
    generate_options: qt_gui
    id: rx_10m_8340
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: damp_factor
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    start: 7.8e9
    step: 1e3
    stop: 9e9
    value: 8340e6
  states: {}
- name: fc_t
  id: variable_qtgui_range
  parameters:
    start: 7e9
    step: 1e3
    stop: 7.8e9
    value: 7239e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '35'
  states: {}
- name: gain_t
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '20'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '122.8e-3'
  states: {}
- name: loop_bw_1
  id: variable
  parameters:
    value: '1e-1'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: samp_rate_t
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: thre
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-6'
    stop: '1e-1'
    value: '1e-3'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '100000'
    n: '280000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: '100000'
    n: '280000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_1
  id: blocks_keep_m_in_n
  parameters:
    m: '100000'
    n: '280000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_2
  id: blocks_keep_m_in_n
  parameters:
    m: '100000'
    n: '280000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '0'
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '70000'
    type: complex
  states: {}
- name: blocks_skiphead_0_1
  id: blocks_skiphead
  parameters:
    num_items: '140000'
    type: complex
  states: {}
- name: blocks_skiphead_0_2
  id: blocks_skiphead
  parameters:
    num_items: '210000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_1_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100000'
    type: complex
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    name: '1'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_0
  id: blocks_tag_debug
  parameters:
    name: 1-a
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_0_0
  id: blocks_tag_debug
  parameters:
    name: 3-a
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_0_1
  id: blocks_tag_debug
  parameters:
    name: 4-a
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_0_2
  id: blocks_tag_debug
  parameters:
    name: 2-a
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_1
  id: blocks_tag_debug
  parameters:
    name: '2'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_2
  id: blocks_tag_debug
  parameters:
    name: '3'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_3
  id: blocks_tag_debug
  parameters:
    name: '4'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    minoutbuf: 70000*4
    ninputs: '4'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw_1
  states: {}
- name: digital_costas_loop_cc_0_2
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw_1
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_map_bb_0_2
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_map_bb_0_3
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_1
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_2
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dslwp_attach_sync_marker_0
  id: dslwp_attach_sync_marker
  parameters:
    check_length: 'False'
    data_format: '2'
    marker: '[0x1a, 0xcf, 0xfc, 0x1d]'
    msg_len: '1020'
    pass_other_length: 'True'
  states: {}
- name: hsdec_qpsk_frame_sync_0
  id: hsdec_qpsk_frame_sync
  parameters:
    block_size: 70000*2
    code: '0x1acffc1d'
    len: '1020'
  states: {}
- name: hsdec_qpsk_frame_sync_0_0
  id: hsdec_qpsk_frame_sync
  parameters:
    block_size: 70000*2
    code: '0x1acffc1d'
    len: '1020'
  states: {}
- name: hsdec_qpsk_frame_sync_0_1
  id: hsdec_qpsk_frame_sync
  parameters:
    block_size: 70000*2
    code: '0x1acffc1d'
    len: '1020'
  states: {}
- name: hsdec_qpsk_frame_sync_0_2
  id: hsdec_qpsk_frame_sync
  parameters:
    block_size: 70000*2
    code: '0x1acffc1d'
    len: '1020'
  states: {}
- name: hsdec_qpsk_packet_filter_0
  id: hsdec_qpsk_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_qpsk_packet_filter_0_0
  id: hsdec_qpsk_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_qpsk_packet_filter_0_1
  id: hsdec_qpsk_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: hsdec_qpsk_packet_filter_0_2
  id: hsdec_qpsk_packet_filter
  parameters:
    chunk_size: '70000'
    sps: '2'
  states: {}
- name: lilacsat_sync_det_b_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_2
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '1'
    type: ccc
  states: {state: bypassed}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc-6600e6
    gain0: gain
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_skiphead_0, '0']
- [analog_agc_xx_0, '0', blocks_skiphead_0_0, '0']
- [analog_agc_xx_0, '0', blocks_skiphead_0_1, '0']
- [analog_agc_xx_0, '0', blocks_skiphead_0_2, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_keep_m_in_n_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_keep_m_in_n_0_1, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [blocks_keep_m_in_n_0_2, '0', blocks_stream_to_tagged_stream_0_1_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_skiphead_0_0, '0', blocks_keep_m_in_n_0_0, '0']
- [blocks_skiphead_0_1, '0', blocks_keep_m_in_n_0_1, '0']
- [blocks_skiphead_0_2, '0', blocks_keep_m_in_n_0_2, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', digital_symbol_sync_xx_0_1, '0']
- [blocks_stream_to_tagged_stream_0_1_0, '0', digital_symbol_sync_xx_0_2, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_null_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', lilacsat_sync_det_b_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_map_bb_0_2, '0']
- [digital_constellation_decoder_cb_0_0_1, '0', digital_map_bb_0_3, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0_1, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_costas_loop_cc_0_1, '0', qtgui_const_sink_x_0_1, '0']
- [digital_costas_loop_cc_0_2, '0', digital_constellation_decoder_cb_0_0_1, '0']
- [digital_costas_loop_cc_0_2, '0', qtgui_const_sink_x_0_2, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_map_bb_0, '0', hsdec_qpsk_frame_sync_0, '0']
- [digital_map_bb_0_0, '0', hsdec_qpsk_frame_sync_0_0, '0']
- [digital_map_bb_0_2, '0', hsdec_qpsk_frame_sync_0_2, '0']
- [digital_map_bb_0_3, '0', hsdec_qpsk_frame_sync_0_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0_1, '0', digital_costas_loop_cc_0_1, '0']
- [digital_symbol_sync_xx_0_2, '0', digital_costas_loop_cc_0_2, '0']
- [dslwp_attach_sync_marker_0, out, blocks_message_debug_0, print]
- [dslwp_attach_sync_marker_0, out, network_socket_pdu_1, pdus]
- [hsdec_qpsk_frame_sync_0, '0', blocks_tag_debug_1_0, '0']
- [hsdec_qpsk_frame_sync_0, '0', hsdec_qpsk_packet_filter_0, '0']
- [hsdec_qpsk_frame_sync_0_0, '0', blocks_tag_debug_1_0_2, '0']
- [hsdec_qpsk_frame_sync_0_0, '0', hsdec_qpsk_packet_filter_0_0, '0']
- [hsdec_qpsk_frame_sync_0_1, '0', blocks_tag_debug_1_0_1, '0']
- [hsdec_qpsk_frame_sync_0_1, '0', hsdec_qpsk_packet_filter_0_2, '0']
- [hsdec_qpsk_frame_sync_0_2, '0', blocks_tag_debug_1_0_0, '0']
- [hsdec_qpsk_frame_sync_0_2, '0', hsdec_qpsk_packet_filter_0_1, '0']
- [hsdec_qpsk_packet_filter_0, '0', blocks_tag_debug_1, '0']
- [hsdec_qpsk_packet_filter_0, '0', blocks_tagged_stream_mux_0, '0']
- [hsdec_qpsk_packet_filter_0_0, '0', blocks_tag_debug_1_1, '0']
- [hsdec_qpsk_packet_filter_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [hsdec_qpsk_packet_filter_0_1, '0', blocks_tag_debug_1_2, '0']
- [hsdec_qpsk_packet_filter_0_1, '0', blocks_tagged_stream_mux_0, '2']
- [hsdec_qpsk_packet_filter_0_2, '0', blocks_tag_debug_1_3, '0']
- [hsdec_qpsk_packet_filter_0_2, '0', blocks_tagged_stream_mux_0, '3']
- [lilacsat_sync_det_b_0, out, dslwp_attach_sync_marker_0, in]
- [rational_resampler_xxx_0, '0', analog_agc_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1

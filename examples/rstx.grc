options:
  parameters:
    author: clouda
    generate_options: qt_gui
    id: rstx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    start: 70e6
    step: 1e3
    stop: 1e9
    value: 70e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: t_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '55'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/clouda/Desktop/test2_output7.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repack_bits_bb_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_2_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-0.707,0.707]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-0.707j,0.707j]'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,0,1,1]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,0,1]'
  states: {}
- name: hsdec_send_pack_0
  id: hsdec_send_pack
  parameters: {}
  states: {}
- name: lilacsat_encode27_bb_0_0
  id: lilacsat_encode27_bb
  parameters: {}
  states: {}
- name: lilacsat_encode27_bb_0_1
  id: lilacsat_encode27_bb
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: t_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_repeat_0, '0']
- [blocks_file_source_0_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_map_bb_0_0, '0']
- [blocks_repack_bits_bb_2, '0', lilacsat_encode27_bb_0_0, '0']
- [blocks_repack_bits_bb_2_0, '0', lilacsat_encode27_bb_0_1, '0']
- [blocks_repeat_0, '0', uhd_usrp_sink_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_add_xx_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_add_xx_0, '1']
- [digital_map_bb_0, '0', blocks_repack_bits_bb_2, '0']
- [digital_map_bb_0_0, '0', blocks_repack_bits_bb_2_0, '0']
- [hsdec_send_pack_0, '0', blocks_repack_bits_bb_0, '0']
- [lilacsat_encode27_bb_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [lilacsat_encode27_bb_0_1, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [network_socket_pdu_0, pdus, hsdec_send_pack_0, in]

metadata:
  file_format: 1

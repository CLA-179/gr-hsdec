options:
  parameters:
    author: clouda
    generate_options: qt_gui
    id: bpskviaaudio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: if_rate
  id: variable
  parameters:
    value: 3600/2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3600'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: if_rate
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: if_rate
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*2
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '-1'
    freq: if_rate
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '-1'
    freq: if_rate
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*2
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_T
    period: '100'
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: '2'
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1,1]'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.065'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {state: disabled}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[1,0]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '2'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dslwp_attach_sync_marker_0
  id: dslwp_attach_sync_marker
  parameters:
    check_length: 'False'
    data_format: '2'
    marker: '[0x1a, 0xcf, 0xfc, 0x1d]'
    msg_len: '100'
    pass_other_length: 'True'
  states: {state: disabled}
- name: hsdec_variable_pack_dec_0
  id: hsdec_variable_pack_dec
  parameters:
    call: '0'
    order: '2'
  states: {}
- name: hsdec_variable_pack_enc_0
  id: hsdec_variable_pack_enc
  parameters:
    call: BG2FWT
    preamble_len: '1024'
  states: {}
- name: lilacsat_sync_det_b_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '100'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {state: disabled}
- name: lilacsat_sync_det_b_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '100'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '8001'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xff'
    maxsize: '100'
    minsize: '100'
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    label1: A
    legend: 'False'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*2
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '1'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: audio
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: audio
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '1']
- [analog_sig_source_x_0_1_0, '0', blocks_multiply_xx_0_1_0, '1']
- [blocks_add_xx_0, '0', blocks_repeat_1, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_1, '0']
- [blocks_complex_to_real_1, '0', digital_binary_slicer_fb_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_1_0, '0', blocks_float_to_complex_0, '1']
- [blocks_repeat_0, '0', blocks_complex_to_float_0, '0']
- [blocks_repeat_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_repeat_1, '0', virtual_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_map_bb_0, '0']
- [digital_binary_slicer_fb_0, '0', hsdec_variable_pack_dec_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_map_bb_0, '0', digital_map_bb_0_0, '0']
- [digital_map_bb_0, '0', lilacsat_sync_det_b_0_0, '0']
- [digital_map_bb_0_0, '0', lilacsat_sync_det_b_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [dslwp_attach_sync_marker_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [hsdec_variable_pack_dec_0, out, blocks_message_debug_0, print]
- [hsdec_variable_pack_dec_0, out, virtual_sink_1, '0']
- [hsdec_variable_pack_enc_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [lilacsat_sync_det_b_0, out, blocks_message_debug_0, print]
- [lilacsat_sync_det_b_0_0, out, blocks_message_debug_0, print]
- [network_socket_pdu_0, pdus, hsdec_variable_pack_enc_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [pdu_random_pdu_0, pdus, dslwp_attach_sync_marker_0, in]
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_0, '1']
- [virtual_source_0, '0', blocks_multiply_xx_0_1_0, '0']
- [virtual_source_1, '0', network_socket_pdu_0, pdus]

metadata:
  file_format: 1
